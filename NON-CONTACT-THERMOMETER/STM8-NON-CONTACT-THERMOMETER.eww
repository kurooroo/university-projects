<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM8-NON-CONTACT-THERMOMETER.ewp</path>
    </project>
    <batchBuild />
</workspace>
